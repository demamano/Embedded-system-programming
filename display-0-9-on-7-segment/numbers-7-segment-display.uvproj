# Keil uVision project numbers-7-segment-display.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: numbers-7-segment-display +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 7-segment-display.c
