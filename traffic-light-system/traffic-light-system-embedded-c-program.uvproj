# Keil uVision project traffic-light-system-embedded-c-program.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: traffic-light-system-embedded-c-program +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: traffic-light.c
