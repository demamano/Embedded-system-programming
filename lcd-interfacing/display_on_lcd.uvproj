# Keil uVision project display_on_lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: display_on_lcd +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Embedded-system-programming
  group Source Group 1
    ./: led.c
