# Keil uVision project visitor-counter-atmel.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: visitor-counter-atmel +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: visit-counter.c
